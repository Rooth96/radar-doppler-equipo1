options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: analysis_rate
  id: variable
  parameters:
    value: sample_rate/10
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '99300000'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: gain_db
  id: variable
  parameters:
    value: '20'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: '240000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '10'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: analysis_rate
    fc: '0'
    fftsize: fft_size
    name: '"Espectro Doppler - Alta Resolucion"'
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: analysis_rate
    fc: '0'
    fftsize: fft_size
    int_max: '-40'
    int_min: '-120'
    name: '"Waterfall Doppler - Alta Resolucion"'
    type: complex
    update_time: '0.5'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: gain_db
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sample_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
