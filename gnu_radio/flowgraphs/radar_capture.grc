options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: analysis_rate
  id: variable
  parameters:
    value: sample_rate/10
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: station_freq + tune_offset
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: gain_db
  id: variable
  parameters:
    value: '20'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: station_freq
  id: variable
  parameters:
    value: '99300000'
  states: {}
- name: tune_offset
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: analysis_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-tune_offset'
    decim: '10'
    samp_rate: sample_rate
    taps: firdes.low_pass(1.0, sample_rate, 100000, 20000, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: analysis_rate
    fc: '0'
    fftsize: fft_size
    name: '"Espectro Doppler - Alta Resolucion"'
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: analysis_rate
    fc: '0'
    fftsize: fft_size
    int_max: '-40'
    int_min: '-120'
    name: '"Waterfall Doppler - Alta Resolucion"'
    type: complex
    update_time: '0.5'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: gain_db
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sample_rate
    sync: none
    type: fc32
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import json
      from pathlib import Path
      from datetime import datetime

      repo_root = Path(__file__).resolve().parents[2]
      config_dir = repo_root / "config"
      config_dir.mkdir(parents=True, exist_ok=True)

      config = {
          "timestamp": datetime.now().astimezone().isoformat(timespec="seconds"),
          "center_frequency_hz": float(self.center_freq),
          "sample_rate_hz": float(self.sample_rate),
          "gain_db": float(self.gain_db),
          "fft_size": int(self.fft_size),
          "frequency_resolution_hz": float(self.analysis_rate / self.fft_size),
          "window_type": "blackman-harris",
          "source_device": "RTL-SDR EQ-2"
      }

      with open(config_dir / "sdr_config.json", "w", encoding="utf-8") as f:
          json.dump(config, f, indent=2)

      print("SDR config guardada en:", config_dir / "sdr_config.json")
    section: main_after_init
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
